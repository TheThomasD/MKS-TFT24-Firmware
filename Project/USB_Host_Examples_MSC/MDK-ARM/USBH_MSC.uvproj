# Keil uVision project USBH_MSC.uvproj, settings and files
target ??IV?STM3210C-EVAL_USBH-FS (6190000::V6.19::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mkstft28 +hex
  AfterMake: fromelf  --bin  -o   ./out/mkstft28.bin  ./out/mkstft28.axf
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=2 v6LangP=5 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210C_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\Utilities\Third_Party\fat_fs\inc;..\src\uart_model;..\src\sd_drv\SD;..\src\sd_drv\SPI;..\src\sd_drv\sys;..\src\spi_flash;..\src\QRENCODE;..\src\Multi_language;..\..\..\Libraries\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../src/: stm32fxxx_it.c usb_bsp.c main.c usbh_usr.c xprintf.c SZ_STM32F107VC_LIB.c Printer.c draw_ready_print.c draw_ui.c draw_print_file.c pic.c draw_printing.c gcode.c draw_move_motor.c draw_about.c draw_change_speed.c draw_extrusion.c draw_language.c draw_operate.c draw_pause_ui.c draw_pre_heat.c draw_set.c draw_Sprayer.c printing_thread.c draw_zero.c id_manage.c fontHz18.c touch_calibrate.c sd_usr.c draw_disk.c string_deal.c bak_cfg_inf.c draw_fan.c draw_dialog.c delay.c fs_usr.c wifi_module.c draw_wifi.c draw_more.c i2c_ee.c draw_printing_moremenu.c mytext.c mks_fontHz14.c draw_filamentchange.c draw_leveling.c draw_tool.c wifi_upload.c draw_bind.c draw_FileTransfer_ui.c draw_babystep.c
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
    ../src/spi_flash/: SPI_FLASH.c
    ../src/Multi_language/: multi_language.c fontHz14.c
    ../../../Libraries/GUI/: GUI.lib
  group USB Host
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c
  group FAT FS
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c fattime.c diskio.c
    ../../../Utilities/Third_Party/fat_fs/src/option/: mycc936.c
  group STM32F10x
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s
    ../src/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c
  group STM3210C_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_spi_sd.c stm3210c_eval_ioe.c SZ_TouchScreen.c stm3210c_eval_lcd.c
  group UART_MODEL
    ../src/uart_model/: mks_tft_fifo.C mks_tft_gcode.C MKS_USART2_IT.C mks_tft_function.c mks_tft_protocol.c mks_tft_test.c mks_tft_reprint.c
  group SD_DRV
    ../src/sd_drv/SD/: MMC_SD.C
    ../src/sd_drv/SPI/: spi.c
    ../src/sd_drv/sys/: sys.c
  group QRENCODE
    ../src/QRENCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
target STM322xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM322xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: STM322xG-EVAL_HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM324xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL_HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM324xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: STM324xG-EVAL_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
